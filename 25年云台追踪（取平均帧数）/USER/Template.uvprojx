# Keil uVision project Template.uvprojx, settings and files
target Template (5060960::V5.06 update 7 (build 960)::.\Version5.06)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: Template
  c flags: Optim=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\FWLIB\inc;..\SYSTEM\oled;..\SYSTEM\moter;..\SYSTEM\Timer;..\SYSTEM\Encoder;..\SYSTEM\pid;..\SYSTEM\bsp_usart;..\SYSTEM\instruct;..\SYSTEM\seek_line;..\SYSTEM\sys;..\SYSTEM\key;..\SYSTEM\pulse
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: serial_tune.c main.c stm32f4xx_it.c system_stm32f4xx.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ./: 引脚.txt
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma2d.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/oled/: oled.c
    ../SYSTEM/moter/: Moter.c
    ../SYSTEM/Timer/: Timer.c
    ../SYSTEM/Encoder/: Encoder.c
    ../SYSTEM/bsp_usart/: bsp_usart.c
    ../SYSTEM/pid/: increpid.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/seek_line/: seek_line.c
    ../SYSTEM/key/: key.c
    ../SYSTEM/pulse/: Pluse.c
    ./: tof050f.c tof050f.h UART_maxcam.c UART_maxcam.h aim_control.h
  group README
    ../: readme.txt
    ./: board.c board.h Emm_V5.c Emm_V5.h fifo.c fifo.h usart.c usart.h
